# Keil uVision project 24.02.2020.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: 24.02.2020
  c flags: Optim=1
  group Source Group 1
    ./: test.s lab_24.02.s lab_09.03.s odev1.s
